Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-08T10:25:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 08 10:25:35 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{BDB2DCE5-99C8-4AB5-8E92-150DF050DB28}\ifc * Database version: 5507 * Database creation date: Wed Nov 08 10:25:34 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 08 10:25:35 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 08 10:25:35 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront, 14708602001b:dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront:194077
In: Level 1
Pset_BuildingElementProxyCommon - Reference: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront
Pset_ManufacturerTypeInformation - ModelReference: 45-35-72/368; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1; Default Elevation: 1219.2 mm
Dimensions - Area: 0.0769225 m2; Volume: 0.00441239 m3; AxisPosition: 13 mm; BarDiameter: 14 mm; BracketHeight: 110 mm; BracketRadius: 4 mm; BracketWidth: 19 mm; Length: 294 mm; Overhang: 125.5 mm; Protrusion: 10 mm; RollHolderDiameter: 212 mm; TopLength: 139 mm; Width: 650 mm
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Generic Models; Family: 14708602001b: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; Family and Type: 14708602001b: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14708602001b: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; Type Id: 14708602001b: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; WarrantyStartDate: 1900-12-31T23:59:59; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: n/a; Constituents: Toilet roll holder; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14708602001b; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 316 stainless steel; ModelNumber: n/a; ModelReference: 45-35-72/368; Name: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; ReplacementCost: n/a; Shape: n/a; Size: 212 x 212 x 125.5 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
Phasing - Phase Created: New Construction
General - Author: Gytautas Balevičius; BIMObjectName: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 10 28 16; MasterFormat2014Description: Bath Accessories; NBSCertification: n/a; NBSDescription: Toilet roll holders; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/368; NBSTypeID: n/a; OmniclassCode: 23-31 25 00; OmniclassDescription: Toilet and Bath Specialties; ProductFamily: Sanitary; ProductGroup: Toilet roll holder; ProductInformation: http://dline.com/product/knud-holscher-collection-toilet-roll-holder-maxi/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=o212mm-steel-front-plate#; ProductionCountry: Lithuania; ProductSKU: 14708602001; Revision: n/a; Uniclass2015Code: Pr_40_20_76_88; Uniclass2015Title: Toilet roll holders; Uniclass2015Version: Products v1.5; UNSPSCCode: 30181610; Version: 1; Weight Net (kg): 0
Identity Data - Description: AISI 316 stainless steel, Maxi toilet roll holder; Manufacturer: info@dline.com; Type Name: dline_Sanitary_MaxiToiletRollHolder_Small_SteelFront
Materials and Finishes - MainMaterial: AISI 316
